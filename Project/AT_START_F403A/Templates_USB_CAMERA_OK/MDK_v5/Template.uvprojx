# Keil uVision project Template.uvprojx, settings and files
target Template (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: AT32F403AVGT7 ArteryTek
  pack: Keil.AT32F4xx_DFP.1.3.1
  cpu: IRAM(0x20000000,0x38000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Template +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1
  c define: AT32F403AVGT7,LIBRARY_VERSION,USE_FULL_ASSERT,AT_START_F403A_V1_0
  c include: ..\..\..\..\Libraries\AT32F4xx_StdPeriph_Driver\inc;..\..\..\..\Libraries\CMSIS\CM4\CoreSupport;..\..\..\..\Libraries\CMSIS\CM4\DeviceSupport;..\..\Templates;..\..\..\AT32_Board;..\apps;..\inc;..\..\..\..\Middlewares\AT32_USB-FS-Device_Driver\inc;..\wm8988-driver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x38000
  group USER
    ../: main.c at32f4xx_it.c
    ../apps/: lcd.c ov2640.c sccb.c touch.c
  group USB
    ../src/: hw_config.c usb_desc.c usb_endp.c usb_prop.c usb_pwr.c at32_audio_conf.c usb_istr.c uvcstream.c
    ../../../../Middlewares/AT32_USB-FS-Device_Driver/src/: usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c usb_sil.c
    ../wm8988-driver/src/: wm8988.c wm8988_i2c.c wm8988_i2s.c
  group BSP
    ../../../AT32_Board/: at32_board.c
  group CMSIS
    ../: system_at32f4xx.c
    ../../../../Libraries/CMSIS/CM4/DeviceSupport/startup/mdk/: startup_at32f403avgt7.s
  group AT32Periph
    ../../../../Libraries/AT32F4xx_StdPeriph_Driver/src/: at32f4xx_adc.c at32f4xx_bkp.c at32f4xx_can.c at32f4xx_crc.c at32f4xx_dac.c at32f4xx_dbgmcu.c at32f4xx_dma.c at32f4xx_exti.c at32f4xx_flash.c at32f4xx_gpio.c at32f4xx_i2c.c at32f4xx_iwdg.c at32f4xx_pwr.c at32f4xx_rcc.c at32f4xx_rtc.c at32f4xx_sdio.c at32f4xx_spi.c at32f4xx_tim.c at32f4xx_usart.c at32f4xx_wwdg.c at32f4xx_xmc.c misc.c at32f4xx_acc.c
  group README
    ../: readme.txt

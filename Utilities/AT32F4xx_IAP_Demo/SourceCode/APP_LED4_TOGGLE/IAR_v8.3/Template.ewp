# IAR project Template.ewp, settings and files
configuration 403_Project (ARM, debug)
  General.OGChipSelectEditMenu: AT32F403ZG ArteryTek AT32F403ZG
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: AT32F403Zx_XL; LIBRARY_VERSION; AT_START_F403_V1_2; SYSCLK_FREQ_192MHz
  ICCARM.CCIncludePath2: ..\..\..\..\..\Libraries\AT32F4xx_StdPeriph_Driver\inc; ..\..\..\..\..\Libraries\CMSIS\CM4\CoreSupport; ..\..\..\..\..\Libraries\CMSIS\CM4\DeviceSupport; ..; ..\SYSTEM
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: APP_LED4_TOGGLE_403.bin
  ILINK.IlinkOutputFile: Template.out
  ILINK.IlinkIcfFile: AT32F403xG.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration 413_Project (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: AT32F413RC ArteryTek AT32F413RC
  ICCARM.CCDefines: AT32F413Rx_HD; LIBRARY_VERSION; AT_START_F413_V1_0; SYSCLK_FREQ_192MHz
  OBJCOPY.OOCOutputFile: APP_LED4_TOGGLE_413.bin
  ILINK.IlinkIcfFile: AT32F413xC.icf
configuration 415_Project (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: AT32F415RCT7 ArteryTek AT32F415RCT7
  General.FPU2: 0
  ICCARM.CCDefines: AT32F415RCT7; LIBRARY_VERSION; AT_START_F415_V1_0; SYSCLK_FREQ_192MHz
  OBJCOPY.OOCOutputFile: APP_LED4_TOGGLE_415.bin
  ILINK.IlinkIcfFile: AT32F415xC.icf
  group AT32Periph
    ../../../../../Libraries/AT32F4xx_StdPeriph_Driver/src/: at32f4xx_flash.c at32f4xx_gpio.c at32f4xx_rcc.c at32f4xx_tim.c at32f4xx_usart.c misc.c
  group CMSIS
    ../../../../../Libraries/CMSIS/CM4/DeviceSupport/startup/iar/: startup_at32f403zx_xl.s startup_at32f413rx_hd.s startup_at32f415rct7.s
    ../: system_at32f4xx.c
  group SYSTEM
    ../SYSTEM/: iap.c led.c usart.c
  group USER
    ../: at32f4xx_it.c main.c
